# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F100, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\Library\inc;..\HARDWARE\beep;..\HARDWARE\EXTI;..\HARDWARE\GPIO;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\timer;..\HARDWARE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../Startup/: startup_stm32f10x_ld.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ../User/: main.c comm.c
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/IIC/: IIC.c dis.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
